# IAR project mkstft70.ewp, settings and files
configuration mkstft70 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; STM32F40_41xxx; USE_HAL_LIB; TFT35
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: ..\Inc\dump_define.h
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Middlewares\Third_Party\FatFs\src\drivers; ..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Middlewares\Third_Party\FatFs\src; ..\Drivers\CMSIS\Include; ..\Drivers\STM32F4xx_MKS_Driver\Inc; ..\Drivers\STM32F4xx_MKS_Driver\Src; ..\Drivers\libstmf4; ..\Drivers\libstmf4\include; ..\Middlewares\Repetier; ..\Middlewares\Repetier\inc_dumb; ..\Middlewares\Repetier\inc_reserve; ..\Middlewares\arduino\stm32\cores\arduino; ..\User\ui; ..\User\others; ..\Middlewares\Ucgui; ..\Middlewares\Ucgui\GUI\ConvertColor; ..\Middlewares\Ucgui\GUI\ConvertMono; ..\Middlewares\Ucgui\GUI\Core; ..\Middlewares\Ucgui\GUI\Font; ..\Middlewares\Ucgui\GUI\AntiAlias; ..\Middlewares\Ucgui\GUI\GUIDemo; ..\Middlewares\Ucgui\GUI\LCDDriver; ..\Middlewares\Ucgui\GUI\MemDev; ..\Middlewares\Ucgui\GUI\MultiLayer; ..\Middlewares\Ucgui\GUI\Widget; ..\Middlewares\Ucgui\GUI\WM; ..\Middlewares\Ucgui\GUI_X; ..\Middlewares\Ucgui\Config; ..\User\uart_model; ..\User\others\Multi_language; ..\User\others\QRENCODE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: mkstft70.bin
  ILINK.IlinkOutputFile: mkstft70.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mksRobinPro (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; STM32F40_41xxx; USE_HAL_LIB
  ICCARM.PreInclude: E:\MKS TFT70 V1.0_001 ZL\cs6\mkstft70\trunk\mkstft70\Middlewares\Repetier\dump_define.h
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include; ../Drivers/STM32F4xx_MKS_Driver/Inc; ../Drivers/STM32F4xx_MKS_Driver/Src; ../Drivers/libstmf4; ../Drivers/libstmf4/include; ../Middlewares/Repetier; ../Middlewares/Repetier/inc_dumb; ../Middlewares/Repetier/inc_reserve; ../Middlewares/arduino/stm32/cores/arduino; ../User/ui; ../User/others; ../Middlewares/Ucgui; ../Middlewares/Ucgui/GUI/ConvertColor; ../Middlewares/Ucgui/GUI/ConvertMono; ../Middlewares/Ucgui/GUI/Core; ../Middlewares/Ucgui/GUI/Font; ../Middlewares/Ucgui/AntiAlias; ../Middlewares/Ucgui/GUI/GUIDemo; ../Middlewares/Ucgui/GUI/LCDDriver; ../Middlewares/Ucgui/GUI/MemDev; ../Middlewares/Ucgui/GUI/MultiLayer; ../Middlewares/Ucgui/GUI/Widget; ../Middlewares/Ucgui/GUI/WM; ../Middlewares/Ucgui/GUI_X; ../Middlewares/Ucgui/Config; ..\User\uart_model
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: adc.c bsp_driver_sd.c dac.c dma.c fatfs.c fsmc.c gpio.c i2c.c iwdg.c main.cpp rtc.c sdio.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c usb_host.c usbh_conf.c
  group Application/User/others
    ../User/others/Multi_language/: Font24_MS.c Helvetica26.c Helvetica36.c multi_language.cpp
    ../User/others/: fontHz18.c fs_usr.cpp ili9320.c mks_cfg.cpp mks_fontHz14.c mks_touch_screen.c pic.c pic_manager.cpp sd_usr.cpp string_deal.c touch_calibrate.cpp wifi_module.cpp wifi_upload.cpp
  group Application/User/QRENCODE
    ../User/others/QRENCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group Application/User/uart_model
    ../User/uart_model/: mks_tft_fifo.cpp mks_tft_function.c mks_tft_gcode.cpp mks_tft_protocol.c mks_tft_reprint.cpp mks_tft_test.cpp MKS_USART2_IT.cpp
  group Application/User/UI
    ../User/ui/: draw_about.cpp draw_acceleration.cpp draw_advanced.cpp draw_babyStep.cpp draw_baud_rate.cpp draw_bind.cpp draw_buttonConf.cpp draw_change_speed.cpp draw_current_settings.cpp draw_CustomConf.cpp draw_dialog.cpp draw_disk.cpp draw_display_conf.cpp draw_extrusion.cpp draw_fan.cpp draw_filament_settings.cpp draw_filamentchange.cpp draw_FileTransfer_ui.cpp draw_firmware_type.cpp draw_keyboard.cpp draw_language.cpp draw_leveling_settings.cpp draw_levelingPara_config.cpp draw_log_ui.cpp draw_machine.cpp draw_machine_para.cpp draw_machine_settings.cpp draw_machine_type.cpp draw_main.cpp draw_manual_leveling.cpp draw_MaxFeedRate.cpp draw_more.cpp draw_MoreBtns.cpp draw_motor_settings.cpp draw_move_motor.cpp draw_number_key.cpp draw_operate.cpp draw_Pause_pos.cpp draw_pause_ui.cpp draw_pre_heat.cpp draw_print_file.cpp draw_printing.cpp draw_printing_moremenu.cpp draw_printMoreBtn.cpp draw_ready_print.cpp draw_set.cpp draw_Sprayer.cpp draw_steps.cpp draw_temp_ui.cpp draw_temperature_settings.cpp draw_Tips.cpp draw_TMC_sensitivity.cpp draw_tool.cpp draw_ui.cpp draw_wifi.cpp draw_wifi_list.cpp draw_XYZLevelPara.cpp draw_zero.cpp draw_zoffset.cpp id_manage.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/libstmf4
    ../Drivers/libstmf4/source/: misc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Drivers/STM32F4xx_MKS_Driver
    ../Drivers/STM32F4xx_MKS_Driver/Src/: spi_flash.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: mycc936.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c usbh_diskio.c
  group Middlewares/UCGUI/ConverColor
    ../Middlewares/Ucgui/GUI/ConvertColor/: LCDP111.c LCDP222.c LCDP233.c LCDP323.c LCDP332.c LCDP444_12.c LCDP444_12_1.c LCDP444_16.c LCDP555.c LCDP556.c LCDP565.c LCDP655.c LCDP8666.c LCDP8666_1.c LCDPM233.c LCDPM323.c LCDPM332.c LCDPM444_12.c LCDPM444_16.c LCDPM555.c LCDPM556.c LCDPM565.c LCDPM655.c
  group Middlewares/UCGUI/ConverMono
    ../Middlewares/Ucgui/GUI/ConvertMono/: LCDP0.c LCDP2.c LCDP4.c
  group Middlewares/UCGUI/Core
    ../Middlewares/Ucgui/GUI/Core/: GUI2DLib.c GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectMax.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawHLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_RectsIntersect.c GUI_SaveContext.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIUC0.c GUIVal.c GUIValf.c LCD.c LCD_API.c LCD_DrawBitmap_565.c LCD_DrawBitmap_M565.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c
  group Middlewares/UCGUI/Font
    ../Middlewares/Ucgui/GUI/Font/: F08_1.c F08_ASCII.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c F4x6.c F6x8.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F8x8.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c Hz16.c HzLib_65k.c mks_hzk16.c SimSun16.c
  group Middlewares/UCGUI/GUI_X
    ../Middlewares/Ucgui/GUI_X/: GUI_X.c GUI_X_Touch.c
  group Middlewares/UCGUI/LCDDriver
    ../Middlewares/Ucgui/GUI/LCDDriver/: LCDDummy.c LCDNull.c LCDWin.c
  group Middlewares/UCGUI/Widget
    ../Middlewares/Ucgui/GUI/Widget/: BUTTON.c BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_IsPressed.c BUTTON_SelfDraw.c BUTTON_SetTextAlign.c BUTTON_StreamedBitmap.c CHECKBOX.c CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_SetBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c DIALOG.c DROPDOWN.c DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_DeleteItem.c DROPDOWN_InsertString.c DROPDOWN_ItemSpacing.c DROPDOWN_SetAutoScroll.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextHeight.c EDIT.c EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_GetNumChars.c EDIT_SetCursorAtChar.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c FRAMEWIN.c FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c GUI_ARRAY.c GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c HEADER.c HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_StreamedBitmap.c LISTBOX.c LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c MENU.c MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MULTIEDIT.c MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c PROGBAR.c PROGBAR_Create.c PROGBAR_CreateIndirect.c RADIO.c RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_Image.c RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c SCROLLBAR.c SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetValue.c SCROLLBAR_SetWidth.c SLIDER.c SLIDER_Create.c SLIDER_CreateIndirect.c TEXT.c TEXT_Create.c TEXT_CreateIndirect.c TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c WIDGET.c WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c
  group Middlewares/UCGUI/WM
    ../Middlewares/Ucgui/GUI/WM/: WM.c WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_Move.c WM_MoveChildTo.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_StayOnTop.c WM_Timer.c WM_TimerExternal.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c WMMemDev.c WMTouch.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
